# Keil uVision project 433_315.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: 433_315 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\user\Inc
  group user
    ./: STARTUP.A51
    ./user/: main.c flash.c audio.c display.c key.c IR.c controller.c PCA.c RF.c
    ./user/Inc/: flash.h main.h audio.h display.h key.h IR.h controller.h PCA.h RF.h
